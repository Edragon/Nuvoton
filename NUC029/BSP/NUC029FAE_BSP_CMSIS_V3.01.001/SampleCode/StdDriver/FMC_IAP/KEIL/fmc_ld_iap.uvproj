# Keil uVision project fmc_ld_iap.uvproj, settings and files
target LDROM_code (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: NUC029FAE Nuvoton
  cpu: CLOCK(24000000) CPUTYPE("Cortex-M0")
  output: LDROM_code
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\..\Library\Device\Nuvoton\NUC029FAE\Include;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  link misc: --map --first='startup_NUC029FAE.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC029FAE/Source/: system_NUC029FAE.c
    ../../../../Library/Device/Nuvoton/NUC029FAE/Source/ARM/: startup_NUC029FAE.s
  group User
    ../: LDROM_main.c
  group Library
    ../../../../Library/StdDriver/src/: uart.c sys.c fmc.c
