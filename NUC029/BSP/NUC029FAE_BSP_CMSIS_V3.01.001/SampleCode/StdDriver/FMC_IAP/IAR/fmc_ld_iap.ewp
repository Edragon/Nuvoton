# IAR project fmc_ld_iap.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Mini58DE series Nuvoton Mini58DE series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: $PROJ_DIR$..\..\..\..\..\library\CMSIS\Include; $PROJ_DIR$..\..\..\..\..\library\Device\Nuvoton\NUC029FAE\Include; $PROJ_DIR$..\..\..\..\..\library\StdDriver\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: LDROM_code.bin
  ILINK.IlinkOutputFile: LDROM_code.out
  ILINK.IlinkIcfFile: fmc_ld_iap.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC029FAE/Source/: system_NUC029FAE.c
  group Library
    ../../../../Library/StdDriver/src/: fmc.c sys.c
  group User
    ../: ldrom_main.c
