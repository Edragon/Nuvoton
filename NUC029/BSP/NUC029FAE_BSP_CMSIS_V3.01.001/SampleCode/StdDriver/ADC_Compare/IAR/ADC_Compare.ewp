# IAR project ADC_Compare.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: NUC029AE series Nuvoton NUC029AE series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\NUC029FAE\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ADC.bin
  ILINK.IlinkOutputFile: ADC.out
  ILINK.IlinkIcfFile: ADC_Compare.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC029FAE/Source/IAR/: startup_NUC029FAE.s
    ../../../../Library/Device/Nuvoton/NUC029FAE/Source/: system_NUC029FAE.c
  group Library
    ../../../../Library/StdDriver/src/: adc.c clk.c retarget.c sys.c uart.c
  group User
    ../: main.c
