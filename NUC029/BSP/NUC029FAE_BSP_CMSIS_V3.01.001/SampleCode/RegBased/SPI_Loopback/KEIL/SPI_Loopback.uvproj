# Keil uVision project SPI_Loopback.uvproj, settings and files
target SPI_Loopback (ARM-ADS)
  device: NUC029FAE Nuvoton
  cpu: CLOCK(24000000) CPUTYPE("Cortex-M0")
  output: SPI
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 wLevel=2
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\NUC029FAE\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC029FAE/Source/: system_NUC029FAE.c
    ../../../../Library/Device/Nuvoton/NUC029FAE/Source/ARM/: startup_NUC029FAE.s
  group User
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c sys.c spi.c uart.c clk.c
