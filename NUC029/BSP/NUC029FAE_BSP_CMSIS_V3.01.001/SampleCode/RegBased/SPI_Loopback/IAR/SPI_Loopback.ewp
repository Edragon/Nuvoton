# IAR project SPI_Loopback.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: NUC029AE series Nuvoton NUC029AE series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\NUC029FAE\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SPI_Loopback.bin
  ILINK.IlinkOutputFile: SPI_Loopback.out
  ILINK.IlinkIcfFile: SPI_Loopback.icf
configuration Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCOptLevel: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC029FAE/Source/IAR/: startup_NUC029FAE.s
    ../../../../Library/Device/Nuvoton/NUC029FAE/Source/: system_NUC029FAE.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c
  group User
    ../: main.c
