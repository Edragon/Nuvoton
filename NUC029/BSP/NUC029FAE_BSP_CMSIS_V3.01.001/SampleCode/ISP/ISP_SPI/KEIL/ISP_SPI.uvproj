# Keil uVision project ISP_SPI.uvproj, settings and files
target ISP_SPI (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: Mini51LDE Nuvoton
  cpu: IRAM(0x20000000-0x200007FF) IROM(0-0xFFF) CLOCK(24000000) CPUTYPE("Cortex-M0")
  output: NUC029FAE_ISP_SPI
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 v6Lang=1 v6LangP=1 wLevel=2
  c define: TARGET_Mini51
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\Device\Nuvoton\NUC029FAE\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0x800
  link misc: --map --first='startup_NUC029FAE.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC029FAE/Source/: system_NUC029FAE.c
    ../../../../Library/Device/Nuvoton/NUC029FAE/Source/ARM/: startup_NUC029FAE.s
  group User
    ../: main.c fmc_user.c isp_user.c targetdev.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c fmc.c gpio.c spi.c sys.c timer.c
