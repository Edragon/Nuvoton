# IAR project led.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: NUC029AE series Nuvoton NUC029AE series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\NUC029FAE\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: led.bin
  ILINK.IlinkOutputFile: led.out
  ILINK.IlinkIcfFile: led.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug (ARM, debug)
  as the first configuration, except:
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC029FAE/Source/IAR/: startup_NUC029FAE.s
    ../../../../Library/Device/Nuvoton/NUC029FAE/Source/: system_NUC029FAE.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c gpio.c retarget.c sys.c uart.c
  group User
    ../: main.c
