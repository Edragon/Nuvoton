# Keil uVision project IAP_RBGtrim.uvproj, settings and files
target Target 1 (MCS-51)
  device: N76E885 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0xFF) CLOCK(25000000)
  output: IAP_RBGtrim +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC_160000
  c include: ..\..\Common;..\..\Include
  group Source Group 1
    ./Code/: IAP_RBGtrim.C
  group Startup
    ../../Startup/: STARTUP.A51
  group Common
    ../../Common/: Common.c Delay.c
