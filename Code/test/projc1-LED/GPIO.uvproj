# Keil uVision project GPIO.uvproj, settings and files
target GPIO (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: GPIO +hex
  c flags: Optimize=4 SizeSpeed=1
  c define: FOSC_160000
  c include: ..\..\Include;..\BSP\N76E003_BSP_Keil_C51_V1.0.5\Include;
  group Source Group 1
    H:/Work_git/Nuvoton/Code/BSP/N76E003_BSP_Keil_C51_V1.0.5/Startup/: STARTUP.A51
    ../BSP/N76E003_BSP_Keil_C51_V1.0.5/Common/: Delay.c Common.c
    ./Code/: GPIO.C
